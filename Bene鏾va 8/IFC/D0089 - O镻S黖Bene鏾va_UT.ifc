Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 9fa30d78-5da8-4ac9-8cac-bcd6f381a2ef, NumberOfSaves: 51], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: D0089
Time: 2024-05-22T15:26:39+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENU) - IFC 24.1.1.6

# IfcProject, D0089
LongName: OÚPSŘ; Phase: DSPS

# IfcSite, Default
RefLatitude: 49, 11, 40, 133999; RefLongitude: 16, 36, 49, 660999; RefElevation: 0 mm

# IfcBuilding, Benešova 8
LongName: Benešova 8
Pset_BuildingCommon - NumberOfStoreys: 6

# IfcBuildingStorey: Level:Podlaží hlavní (8)
In: Benešova 8
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
1PP | 1PP | -3950
1NP | 1NP | 0
1NP mezipatro | 1NP mezipatro | 2650
2NP | 2NP | 5500
3NP | 3NP | 10200
4NP | 4NP | 14400
Podkroví | Podkroví | 17600
Střecha | Střecha | 26000

# IfcDistributionPort (280)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_836005_1
Port_836005_2
Port_838780_1
Port_838780_2
Port_843025_1
Port_843025_2
Port_843458_1
Port_843458_2
Port_845788_1
Port_845788_2
Port_845946_1
Port_845946_2
Port_846740_1
Port_846740_2
Port_846754_1
Port_846754_2
Port_847570_1
Port_847570_2
Port_847603_1
Port_847603_2
Port_849588_1
Port_849588_2
Port_849593_1
Port_849593_2
Port_849611_1
Port_849611_2
Port_851180_1
Port_851180_2
Port_851205_1
Port_851205_2
Port_852052_1
Port_852052_2
Port_852117_1
Port_852117_2
Port_852347_1
Port_852347_2
Port_853536_1
Port_853536_2
Port_853654_1
Port_853654_2
Port_853686_1
Port_853686_2
Port_853687_1
Port_853687_2
Port_853714_1
Port_853714_2
Port_853762_1
Port_853762_2
Port_853801_1
Port_853801_2
Port_853866_1
Port_853866_2
Port_853892_1
Port_853892_2
Port_853976_1
Port_853976_2
Port_854020_1
Port_854020_2
Port_854026_1
Port_854026_2
Port_854031_1
Port_854031_2
Port_854055_1
Port_854055_2
Port_854111_1
Port_854111_2
Port_855323_1
Port_855323_2
Port_857252_1
Port_857252_2
Port_857658_1
Port_857658_2
Port_857663_1
Port_857663_2
Port_857727_1
Port_857727_2
Port_857732_1
Port_857732_2
Port_857758_1
Port_857758_2
Port_857837_1
Port_857837_2
Port_857858_1
Port_857858_2
Port_857875_1
Port_857875_2
Port_858272_1
Port_858272_2
Port_858286_1
Port_858286_2
Port_858296_1
Port_858296_2
Port_858307_1
Port_858307_2
Port_858369_1
Port_858369_2
Port_858379_1
Port_858379_2
Port_858384_1
Port_858384_2
Port_858389_1
Port_858389_2
Port_858415_1
Port_858415_2
Port_858436_1
Port_858436_2
Port_859236_1
Port_859236_2
Port_859254_1
Port_859254_2
Port_859276_1
Port_859276_2
Port_859308_1
Port_859308_2
Port_859330_1
Port_859330_2
Port_859371_1
Port_859371_2
Port_861070_1
Port_861070_2
Port_861879_1
Port_861879_2
Port_861895_1
Port_861895_3
Port_861895_4
Port_861895_5
Port_862146_1
Port_862146_3
Port_862146_4
Port_862146_5
Port_862390_1
Port_862390_3
Port_862390_4
Port_862390_5
Port_862728_1
Port_862728_3
Port_862728_4
Port_862728_5
Port_862735_1
Port_862735_3
Port_862735_4
Port_862735_5
Port_862801_1
Port_862801_3
Port_862801_4
Port_862801_5
Port_863663_1
Port_863663_3
Port_863663_4
Port_863663_5
Port_863918_1
Port_863918_2
Port_865583_1
Port_865583_2
Port_866409_1
Port_866409_2
Port_866445_1
Port_866445_2
Port_866467_1
Port_866467_2
Port_866490_1
Port_866490_2
Port_866526_1
Port_866526_2
Port_866596_1
Port_866596_2
Port_866612_1
Port_866612_2
Port_866679_1
Port_866679_2
Port_866748_1
Port_866748_2
Port_869199_1
Port_869199_3
Port_869199_4
Port_869199_5
Port_869240_1
Port_869240_3
Port_869240_4
Port_869240_5
Port_869571_1
Port_869571_3
Port_869571_4
Port_869571_5
Port_869606_1
Port_869606_3
Port_869606_4
Port_869606_5
Port_869885_1
Port_869885_3
Port_869885_4
Port_869885_5
Port_870326_1
Port_870326_3
Port_870326_4
Port_870326_5
Port_870429_1
Port_870429_3
Port_870429_4
Port_870429_5
Port_870972_1
Port_870972_3
Port_870972_4
Port_870972_5
Port_871300_1
Port_871300_3
Port_871300_4
Port_871300_5
Port_871916_1
Port_871916_2
Port_873314_1
Port_873314_2
Port_873524_1
Port_873524_2
Port_873785_1
Port_873785_2
Port_873933_1
Port_873933_2
Port_874065_1
Port_874065_2
Port_874083_1
Port_874083_2
Port_875865_1
Port_875865_2
Port_877240_1
Port_877240_2
Port_877299_1
Port_877299_2
Port_877347_1
Port_877347_2
Port_877447_1
Port_877447_2
Port_878309_1
Port_878309_2
Port_878429_1
Port_878429_2
Port_878488_1
Port_878488_2
Port_878507_1
Port_878507_2
Port_880323_1
Port_880323_2
Port_880464_1
Port_880464_2
Port_880492_1
Port_880492_2
Port_880533_1
Port_880533_2
Port_880680_1
Port_880680_2
Port_880734_1
Port_880734_3
Port_880734_4
Port_880734_5
Port_881863_1
Port_881863_2
Port_881951_1
Port_881951_2
Port_882282_1
Port_882282_2
Port_882333_1
Port_882333_2
Port_882417_1
Port_882417_2
Port_882422_1
Port_882422_2
Port_882436_1
Port_882436_2
Port_882441_1
Port_882441_2
Port_882573_1
Port_882573_2
Port_882589_1
Port_882589_2
Port_882605_1
Port_882605_2
Port_882623_1
Port_882623_2
Port_882713_1
Port_882713_2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:1000/500/66 (26)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1000/500/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:1000/500/66:...) | In
861070 | 2NP
861879 | 2NP
866490 | 2NP
866526 | 2NP
866596 | 2NP
866612 | 2NP
866679 | 2NP
873785 | 1NP
873933 | 1NP
874065 | 1NP
878309 | 1NP
878429 | 1NP
880323 | 1PP
880464 | 1PP
880492 | 1PP
880680 | 1PP
882282 | 1PP
882333 | 1PP
882417 | 1PP
882422 | 1PP
882436 | 1PP
882441 | 1PP
882573 | 1PP
882589 | 1PP
882605 | 1PP
882623 | 1PP

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:1000/550/66 (15)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1000/550/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:1000/550/66:...) | In
853976 | 3NP
854020 | 3NP
854026 | 3NP
854031 | 3NP
857252 | 3NP
857658 | 3NP
857663 | 3NP
857727 | 3NP
857732 | 3NP
857858 | 3NP
857875 | 3NP
858415 | 2NP
859236 | 2NP
859254 | 2NP
859276 | 2NP

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:1000/600/66 (3)
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1000/600/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:1000/600/66:...)
847603
849588
849593

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:1100/550/66, PF_Deskový radiátor_připojení boční:1100/550/66:858436
In: 2NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1100/550/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:1100/600/66 (6)
In: 3NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1100/600/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:1100/600/66:...)
858272
858286
858307
858369
858379
858384

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:1200/500/66 (6)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1200/500/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:1200/500/66:...) | In
838780 | 4NP
853801 | 4NP
873314 | 1NP
873524 | 1NP
877347 | 1NP
881863 | 1PP

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:1200/600/66 (3)
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1200/600/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:1200/600/66:...)
852052
853654
853714

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:1200/900/66, PF_Deskový radiátor_připojení boční:1200/900/66:871916
In: 1NP
Type - Material: Default, <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1200/900/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:1400/500/66, PF_Deskový radiátor_připojení boční:1400/500/66:836005
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1400/500/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:1600/500/66, PF_Deskový radiátor_připojení boční:1600/500/66:863918
In: 2NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1600/500/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:1800/500/66, PF_Deskový radiátor_připojení boční:1800/500/66:859371
In: 2NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1800/500/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:2000/550/66, PF_Deskový radiátor_připojení boční:2000/550/66:866748
In: 2NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 2000/550/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:2300/500/66 (4)
In: 3NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 2300/500/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:2300/500/66:...)
855323
857837
858296
858389

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:500/450/66, PF_Deskový radiátor_připojení boční:500/450/66:874083
In: 1NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 500/450/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:500/500/66 (2)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 500/500/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:500/500/66:...) | In
853536 | 4NP
859330 | 2NP

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:500/550/66, PF_Deskový radiátor_připojení boční:500/550/66:849611
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 500/550/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:500/900/66, PF_Deskový radiátor_připojení boční:500/900/66:878507
In: 1NP
Type - Material: Default, <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 500/900/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:600/500/66, PF_Deskový radiátor_připojení boční:600/500/66:843458
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 600/500/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:700/500/66, PF_Deskový radiátor_připojení boční:700/500/66:854111
In: 3NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 700/500/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:800/300/66 (3)
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 800/300/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:800/300/66:...)
846754
847570
882713

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:800/500/66 (4)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 800/500/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:800/500/66:...) | In
845946 | 4NP
846740 | 4NP
859308 | 2NP
880533 | 1PP

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:800/550/66, PF_Deskový radiátor_připojení boční:800/550/66:854055
In: 3NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 800/550/66; sets with these values: 2

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:800/900/66 (2)
In: 1NP
Type - Material: Default, <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 800/900/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:800/900/66:...)
877447
878488

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:900/450/66 (4)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 900/450/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:900/450/66:...) | In
875865 | 1NP
877240 | 1NP
877299 | 1NP
881951 | 1PP

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:900/500/66 (4)
In: 2NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 900/500/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:900/500/66:...)
865583
866409
866445
866467

# IfcFlowTerminal: PF_Deskový radiátor_připojení boční:Elektrický přímotop_500/300/66 (2)
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Elektrický přímotop_500/300/66; sets with these values: 2
Name (PF_Deskový radiátor_připojení boční:Elektrický přímotop_500/300/66:...)
851180
851205

# IfcFlowTerminal: PF_Topný žebřík_připojení boční:Topný žebřík_450, PF_Topný žebřík_připojení boční:Topný žebřík_450:857758
In: 3NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Topný žebřík_450; sets with these values: 2

# IfcFlowTerminal: PF_Topný žebřík_připojení boční:Topný žebřík_600x1250 (2)
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Topný žebřík_600x1250; sets with these values: 2
Name (PF_Topný žebřík_připojení boční:Topný žebřík_600x1250:...)
843025
853892

# IfcFlowTerminal: PF_Topný žebřík_připojení boční:Topný žebřík_600x1500, PF_Topný žebřík_připojení boční:Topný žebřík_600x1500:845788
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Topný žebřík_600x1500; sets with these values: 2

# IfcFlowTerminal: PF_Topný žebřík_připojení boční:Topný žebřík_600x900 (6)
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Topný žebřík_600x900; sets with these values: 2
Name (PF_Topný žebřík_připojení boční:Topný žebřík_600x900:...)
852117
852347
853686
853687
853762
853866

# IfcFlowTerminal: PF_Žebrový radiátor:1000x400_23 (4)
Type - Material: Litina
Pset_DistributionFlowElementCommon - Reference: 1000x400_23; sets with these values: 2
Name (PF_Žebrový radiátor:1000x400_23:...) | In
862390 | 2NP
862728 | 2NP
862735 | 2NP
869606 | 1NP mezipatro

# IfcFlowTerminal: PF_Žebrový radiátor:1000x550_23, PF_Žebrový radiátor:1000x550_23:870972
In: 2NP
Type - Material: Litina
Pset_DistributionFlowElementCommon - Reference: 1000x550_23; sets with these values: 2

# IfcFlowTerminal: PF_Žebrový radiátor:1200x400_23, PF_Žebrový radiátor:1200x400_23:863663
In: 2NP
Type - Material: Litina
Pset_DistributionFlowElementCommon - Reference: 1200x400_23; sets with these values: 2

# IfcFlowTerminal: PF_Žebrový radiátor:1200x550_23, PF_Žebrový radiátor:1200x550_23:862146
In: 2NP
Type - Material: Litina
Pset_DistributionFlowElementCommon - Reference: 1200x550_23; sets with these values: 2

# IfcFlowTerminal: PF_Žebrový radiátor:400x400_23, PF_Žebrový radiátor:400x400_23:869240
In: 1NP mezipatro
Type - Material: Litina
Pset_DistributionFlowElementCommon - Reference: 400x400_23; sets with these values: 2

# IfcFlowTerminal: PF_Žebrový radiátor:500x550_23, PF_Žebrový radiátor:500x550_23:861895
In: 2NP
Type - Material: Litina
Pset_DistributionFlowElementCommon - Reference: 500x550_23; sets with these values: 2

# IfcFlowTerminal: PF_Žebrový radiátor:600x400_23 (2)
In: 1NP mezipatro
Type - Material: Litina
Pset_DistributionFlowElementCommon - Reference: 600x400_23; sets with these values: 2
Name (PF_Žebrový radiátor:600x400_23:...)
869885
870326

# IfcFlowTerminal: PF_Žebrový radiátor:600x600_23, PF_Žebrový radiátor:600x600_23:880734
In: 1PP
Type - Material: Litina
Pset_DistributionFlowElementCommon - Reference: 600x600_23; sets with these values: 2

# IfcFlowTerminal: PF_Žebrový radiátor:600x950_23, PF_Žebrový radiátor:600x950_23:871300
In: 1NP mezipatro
Type - Material: Litina
Pset_DistributionFlowElementCommon - Reference: 600x950_23; sets with these values: 2

# IfcFlowTerminal: PF_Žebrový radiátor:750x600_23, PF_Žebrový radiátor:750x600_23:870429
In: 1NP mezipatro
Type - Material: Litina
Pset_DistributionFlowElementCommon - Reference: 750x600_23; sets with these values: 2

# IfcFlowTerminal: PF_Žebrový radiátor:850x400_23 (3)
Type - Material: Litina
Pset_DistributionFlowElementCommon - Reference: 850x400_23; sets with these values: 2
Name (PF_Žebrový radiátor:850x400_23:...) | In
862801 | 2NP
869199 | 1NP mezipatro
869571 | 1NP mezipatro
