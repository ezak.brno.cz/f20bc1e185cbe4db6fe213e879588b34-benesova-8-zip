Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: cfd52108-7224-4476-8f90-91bcf0ea9494, NumberOfSaves: 64], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: D0089
Time: 2024-05-22T15:23:31+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENU) - IFC 24.1.1.6

# IfcProject, D0089
LongName: OÚPSŘ; Phase: DSPS

# IfcSite, Default
RefLatitude: 49, 11, 40, 133999; RefLongitude: 16, 36, 49, 660999; RefElevation: 0 mm

# IfcBuilding, Benešova 8
LongName: Benešova 8
Pset_BuildingCommon - NumberOfStoreys: 7

# IfcBuildingStorey: Level:Podlaží hlavní (8)
In: Benešova 8
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
1PP | 1PP | -3950
1NP | 1NP | 0
1NP mezipatro | 1NP mezipatro | 2650
2NP | 2NP | 5500
3NP | 3NP | 10200
4NP | 4NP | 14400
Podkroví | Podkroví | 17600
Střecha | Střecha | 26000

# IfcBuildingElementProxy: EE_FB_Rozvaděč na stěnu:1200x1500, EE_FB_Rozvaděč na stěnu:1200x1500, 0 V, Single Phase, 2 Wires:931960
In: 1NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 1200x1500; sets with these values: 2

# IfcBuildingElementProxy: EE_FB_Rozvaděč na stěnu:1200x2000, EE_FB_Rozvaděč na stěnu:1200x2000, 0 V, Single Phase, 2 Wires:862435
In: 1PP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 1200x2000; sets with these values: 2

# IfcBuildingElementProxy: EE_FB_Rozvaděč na stěnu:500x1000, EE_FB_Rozvaděč na stěnu:500x1000, 0 V, Single Phase, 2 Wires:888938
In: 4NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 500x1000; sets with these values: 2

# IfcBuildingElementProxy: EE_FB_Rozvaděč na stěnu:600x600, EE_FB_Rozvaděč na stěnu:600x600, 0 V, Single Phase, 2 Wires:931766
In: 1NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 600x600; sets with these values: 2

# IfcBuildingElementProxy: EE_FB_Rozvaděč na stěnu:600x900, EE_FB_Rozvaděč na stěnu:600x900, 0 V, Single Phase, 2 Wires:861396
In: 1NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 600x900; sets with these values: 2

# IfcBuildingElementProxy: EE_FB_Rozvaděč na stěnu:700x1000, EE_FB_Rozvaděč na stěnu:700x1000, 0 V, Single Phase, 2 Wires:862086
In: 1PP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 700x1000; sets with these values: 2

# IfcBuildingElementProxy: EE_FB_Rozvaděč na stěnu:800x1200, EE_FB_Rozvaděč na stěnu:800x1200, 0 V, Single Phase, 2 Wires:862021
In: 1PP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 800x1200; sets with these values: 2

# IfcBuildingElementProxy: EE_Rozvaděč zapuštěný do stěny:500x1200 (2)
In: 1NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 500x1200; sets with these values: 2
Name (EE_Rozvaděč zapuštěný do stěny:500x1200, 0 V, Single Phase, 2 Wires:...)
861841
861996

# IfcBuildingElementProxy: EE_Rozvaděč zapuštěný do stěny:500x700 (2)
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 500x700; sets with these values: 2
Name (EE_Rozvaděč zapuštěný do stěny:500x700, 0 V, Single Phase, 2 Wires:...) | In
882668 | 3NP
882768 | 2NP

# IfcBuildingElementProxy: EE_Rozvaděč zapuštěný do stěny:500x800 (3)
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 500x800; sets with these values: 2
Name (EE_Rozvaděč zapuštěný do stěny:...) | In
500x800, 0 V, Single Phase, 2 Wires:862162 | 1PP
500x800, 0 V, Single Phase, 2 Wires:864829 | 1NP mezipatro
500x800:882522 | 3NP

# IfcBuildingElementProxy: EE_Rozvaděč zapuštěný do stěny:550x550, EE_Rozvaděč zapuštěný do stěny:550x550, 0 V, Single Phase, 2 Wires:874042
In: 2NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 550x550; sets with these values: 2

# IfcBuildingElementProxy: EE_Rozvaděč zapuštěný do stěny:600x900 (2)
In: 1NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 600x900; sets with these values: 2
Name (EE_Rozvaděč zapuštěný do stěny:600x900, 0 V, Single Phase, 2 Wires:...)
861648
861804

# IfcBuildingElementProxy: EE_Rozvaděč zapuštěný do stěny:650x480 (2)
In: 1NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 650x480; sets with these values: 2
Name (EE_Rozvaděč zapuštěný do stěny:650x480, 0 V, Single Phase, 2 Wires:...)
951673
951866

# IfcBuildingElementProxy: EF_Hlavní vypinač výtahu:Na stěnu, EF_Hlavní vypinač výtahu:Na stěnu:910226
In: 1PP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Na stěnu; sets with these values: 2

# IfcBuildingElementProxy: EF_Total stop:Hl.vypínač (2)
Type - Material: <Unnamed>, Plast bílý
Pset_BuildingElementProxyCommon - Reference: Hl.vypínač; sets with these values: 2
Name (EF_Total stop:Hl.vypínač:...) | In
909308 | 1PP
930558 | 1NP

# IfcBuildingElementProxy: EF_Vypínač:Dvojklapka (46)
Type - Material: <Unnamed>, Plast bílý
Pset_BuildingElementProxyCommon - Reference: Dvojklapka; sets with these values: 2
Name (EF_Vypínač:Dvojklapka:...) | In
841075 | 1PP
841097 | 1PP
841276 | 1PP
841419 | 1PP
841498 | 1PP
852282 | 1NP
852403 | 1NP
852764 | 1NP
852773 | 1NP
854224 | 1NP
854803 | 1NP
854843 | 1NP
856148 | 1NP
863074 | 1NP mezipatro
863184 | 1NP mezipatro
863191 | 1NP mezipatro
863197 | 1NP mezipatro
863809 | 1NP mezipatro
864151 | 1NP mezipatro
865432 | 1NP mezipatro
866113 | 2NP
866124 | 2NP
866388 | 2NP
866871 | 2NP
867384 | 2NP
867839 | 2NP
867846 | 2NP
869700 | 2NP
870105 | 2NP
870127 | 2NP
873194 | 2NP
873819 | 2NP
873882 | 2NP
875424 | 3NP
877973 | 3NP
878455 | 3NP
878476 | 3NP
880607 | 3NP
880616 | 3NP
880671 | 3NP
880714 | 3NP
880847 | 3NP
885387 | 4NP
887520 | 4NP
887776 | 4NP
888331 | 4NP

# IfcBuildingElementProxy: EF_Vypínač:Jednoklapka (220)
Type - Material: <Unnamed>, Plast bílý
Pset_BuildingElementProxyCommon - Reference: Jednoklapka; sets with these values: 2
Name (EF_Vypínač:Jednoklapka:...) | In
840862 | 1PP
840910 | 1PP
840959 | 1PP
840967 | 1PP
841971 | 1PP
842119 | 1PP
842549 | 1PP
842652 | 1PP
842710 | 1PP
842719 | 1PP
842912 | 1PP
842965 | 1PP
842982 | 1PP
843010 | 1PP
843025 | 1PP
843076 | 1PP
843098 | 1PP
843208 | 1PP
843333 | 1NP
843361 | 1NP
843430 | 1NP
843513 | 1NP
843541 | 1NP
843560 | 1NP
843572 | 1NP
843858 | 1NP
843891 | 1NP
843988 | 1NP
844077 | 1NP
844141 | 1NP
844213 | 1NP
844280 | 1NP
844293 | 1NP
844560 | 1NP
844597 | 1NP
844647 | 1NP
844677 | 1NP
844719 | 1NP
844738 | 1NP
844819 | 1NP
844855 | 1NP
844911 | 1NP
852312 | 1NP
852321 | 1NP
852432 | 1NP
852467 | 1NP
852482 | 1NP
853110 | 1NP
853130 | 1NP
853178 | 1NP
853194 | 1NP
853267 | 1NP
853336 | 1NP
853349 | 1NP
853466 | 1NP
853667 | 1NP
854399 | 1NP
854407 | 1NP
854538 | 1NP
855183 | 1NP
856184 | 1NP
863214 | 1NP mezipatro
863234 | 1NP mezipatro
863303 | 1NP mezipatro
863316 | 1NP mezipatro
863398 | 1NP mezipatro
863412 | 1NP mezipatro
863458 | 1NP mezipatro
863598 | 1NP mezipatro
863772 | 1NP mezipatro
863828 | 1NP mezipatro
863838 | 1NP mezipatro
863872 | 1NP mezipatro
863918 | 1NP mezipatro
864028 | 1NP mezipatro
864054 | 1NP mezipatro
864165 | 1NP mezipatro
864182 | 1NP mezipatro
864192 | 1NP mezipatro
864983 | 1NP mezipatro
865036 | 1NP mezipatro
865416 | 1NP mezipatro
866201 | 2NP
866212 | 2NP
866405 | 2NP
866892 | 2NP
866901 | 2NP
866988 | 2NP
866996 | 2NP
867251 | 2NP
867259 | 2NP
867412 | 2NP
867939 | 2NP
867946 | 2NP
868826 | 2NP
868840 | 2NP
868848 | 2NP
868885 | 2NP
868994 | 2NP
869602 | 2NP
869618 | 2NP
869686 | 2NP
869739 | 2NP
870030 | 2NP
870364 | 2NP
870373 | 2NP
870436 | 2NP
870603 | 2NP
870698 | 2NP
870784 | 2NP
870873 | 2NP
870971 | 2NP
871052 | 2NP
871115 | 2NP
871170 | 2NP
871355 | 2NP
871389 | 2NP
871439 | 2NP
871497 | 2NP
871558 | 2NP
871622 | 2NP
871699 | 2NP
871757 | 2NP
871865 | 2NP
872057 | 2NP
872064 | 2NP
873317 | 2NP
873330 | 2NP
873418 | 2NP
873494 | 2NP
873566 | 2NP
873626 | 2NP
878072 | 3NP
878520 | 3NP
878532 | 3NP
878610 | 3NP
878689 | 3NP
878754 | 3NP
878864 | 3NP
878922 | 3NP
879014 | 3NP
879075 | 3NP
879198 | 3NP
879298 | 3NP
879401 | 3NP
879432 | 3NP
879513 | 3NP
879561 | 3NP
879679 | 3NP
879859 | 3NP
879930 | 3NP
879973 | 3NP
880059 | 3NP
880141 | 3NP
880204 | 3NP
880296 | 3NP
880400 | 3NP
880551 | 3NP
880579 | 3NP
880926 | 3NP
880972 | 3NP
881047 | 3NP
884899 | 4NP
884907 | 4NP
884944 | 4NP
884996 | 4NP
885065 | 4NP
885123 | 4NP
885230 | 4NP
885453 | 4NP
885471 | 4NP
885520 | 4NP
885612 | 4NP
885679 | 4NP
885762 | 4NP
885802 | 4NP
885878 | 4NP
885921 | 4NP
886059 | 4NP
886155 | 4NP
886163 | 4NP
886224 | 4NP
886268 | 4NP
886311 | 4NP
886368 | 4NP
886499 | 4NP
886650 | 4NP
886785 | 4NP
886834 | 4NP
886960 | 4NP
886969 | 4NP
887028 | 4NP
887059 | 4NP
887232 | 4NP
887291 | 4NP
887346 | 4NP
887569 | 4NP
887583 | 4NP
887645 | 4NP
887799 | 4NP
887806 | 4NP
887872 | 4NP
887884 | 4NP
887930 | 4NP
887979 | 4NP
888033 | 4NP
888277 | 4NP
888289 | 4NP
888348 | 4NP
888358 | 4NP
888419 | 4NP
888435 | 4NP
888502 | 4NP
888647 | 4NP
888659 | 4NP
888794 | 4NP
889135 | 2NP
889142 | 2NP
929408 | 1NP
929504 | Podkroví

# IfcBuildingElementProxy: EF_Zásuvka trojfázová:Zásuvka trojfázová (3)
In: 1NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Zásuvka trojfázová; sets with these values: 2
Name (EF_Zásuvka trojfázová:Zásuvka trojfázová:...)
852130
852135
852198

# IfcBuildingElementProxy: EF_Zásuvka:Dvojzásuvka (354)
Type - Material: Plast bílý, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Dvojzásuvka; sets with these values: 2
Name (EF_Zásuvka:Dvojzásuvka:...) | In
842630 | 1PP
852507 | 1NP
852533 | 1NP
852570 | 1NP
852594 | 1NP
852638 | 1NP
852697 | 1NP
852734 | 1NP
852749 | 1NP
852894 | 1NP
852905 | 1NP
852931 | 1NP
853052 | 1NP
853060 | 1NP
853686 | 1NP
853696 | 1NP
853715 | 1NP
853744 | 1NP
853750 | 1NP
853799 | 1NP
853839 | 1NP
853875 | 1NP
853962 | 1NP
854002 | 1NP
854065 | 1NP
854129 | 1NP
854138 | 1NP
854254 | 1NP
854263 | 1NP
854301 | 1NP
854363 | 1NP
854699 | 1NP
854719 | 1NP
855224 | 1NP
855255 | 1NP
855265 | 1NP
855324 | 1NP
855349 | 1NP
855368 | 1NP
855399 | 1NP
855409 | 1NP
855439 | 1NP
855636 | 1NP
855665 | 1NP
855724 | 1NP
855747 | 1NP
855802 | 1NP
855989 | 1NP
856016 | 1NP
856039 | 1NP
856046 | 1NP
856089 | 1NP
856106 | 1NP
856199 | 1NP
856223 | 1NP
863008 | 1NP mezipatro
863024 | 1NP mezipatro
864259 | 1NP mezipatro
865068 | 1NP mezipatro
865090 | 1NP mezipatro
865112 | 1NP mezipatro
865139 | 1NP mezipatro
865222 | 1NP mezipatro
865229 | 1NP mezipatro
865253 | 1NP mezipatro
865290 | 1NP mezipatro
865315 | 1NP mezipatro
868043 | 2NP
868072 | 2NP
868178 | 2NP
868452 | 2NP
868634 | 2NP
868639 | 2NP
868663 | 2NP
868727 | 2NP
868771 | 2NP
869194 | 2NP
869230 | 2NP
869255 | 2NP
869284 | 2NP
869333 | 2NP
869365 | 2NP
869396 | 2NP
869455 | 2NP
869488 | 2NP
869526 | 2NP
869547 | 2NP
869720 | 2NP
869803 | 2NP
869808 | 2NP
869848 | 2NP
869855 | 2NP
869891 | 2NP
869974 | 2NP
870189 | 2NP
870210 | 2NP
870246 | 2NP
870326 | 2NP
872107 | 2NP
872113 | 2NP
872138 | 2NP
872199 | 2NP
872220 | 2NP
872264 | 2NP
872289 | 2NP
872336 | 2NP
872369 | 2NP
872409 | 2NP
872439 | 2NP
872478 | 2NP
872498 | 2NP
872539 | 2NP
872561 | 2NP
872630 | 2NP
872650 | 2NP
872703 | 2NP
872723 | 2NP
872785 | 2NP
872812 | 2NP
872842 | 2NP
872863 | 2NP
872882 | 2NP
872912 | 2NP
872931 | 2NP
872963 | 2NP
872987 | 2NP
873009 | 2NP
873038 | 2NP
873057 | 2NP
873070 | 2NP
873233 | 2NP
873242 | 2NP
873273 | 2NP
873286 | 2NP
874324 | 3NP
874330 | 3NP
874352 | 3NP
874384 | 3NP
874427 | 3NP
874461 | 3NP
874523 | 3NP
874525 | 3NP
874526 | 3NP
874527 | 3NP
874528 | 3NP
874529 | 3NP
874539 | 3NP
874541 | 3NP
874542 | 3NP
874543 | 3NP
874544 | 3NP
874545 | 3NP
874555 | 3NP
874557 | 3NP
874558 | 3NP
874559 | 3NP
874560 | 3NP
874561 | 3NP
874676 | 3NP
874682 | 3NP
874707 | 3NP
874712 | 3NP
874736 | 3NP
874752 | 3NP
874787 | 3NP
874817 | 3NP
874851 | 3NP
874887 | 3NP
874914 | 3NP
875014 | 3NP
875023 | 3NP
875045 | 3NP
875067 | 3NP
875105 | 3NP
875139 | 3NP
875179 | 3NP
875181 | 3NP
875182 | 3NP
875183 | 3NP
875184 | 3NP
875185 | 3NP
875195 | 3NP
875206 | 3NP
875246 | 3NP
875265 | 3NP
875303 | 3NP
875330 | 3NP
875372 | 3NP
875392 | 3NP
875484 | 3NP
875490 | 3NP
875517 | 3NP
875590 | 3NP
875701 | 3NP
875920 | 3NP
876103 | 3NP
876207 | 3NP
876232 | 3NP
876282 | 3NP
876305 | 3NP
876381 | 3NP
876404 | 3NP
876453 | 3NP
876476 | 3NP
876533 | 3NP
876550 | 3NP
876610 | 3NP
876702 | 3NP
876728 | 3NP
876782 | 3NP
876806 | 3NP
876860 | 3NP
876890 | 3NP
876952 | 3NP
876976 | 3NP
877075 | 3NP
877098 | 3NP
877182 | 3NP
877211 | 3NP
877241 | 3NP
877267 | 3NP
877330 | 3NP
877378 | 3NP
877413 | 3NP
877431 | 3NP
877465 | 3NP
877490 | 3NP
877535 | 3NP
877557 | 3NP
877626 | 3NP
877666 | 3NP
877696 | 3NP
877726 | 3NP
877759 | 3NP
877779 | 3NP
877815 | 3NP
877832 | 3NP
877856 | 3NP
877878 | 3NP
877949 | 3NP
878428 | 3NP
880900 | 3NP
881058 | 3NP
881070 | 3NP
881083 | 3NP
881088 | 3NP
881125 | 3NP
881148 | 3NP
881231 | 3NP
881563 | 3NP
881585 | 3NP
881622 | 3NP
881718 | 3NP
881720 | 3NP
881736 | 3NP
881738 | 3NP
881739 | 3NP
881748 | 3NP
881750 | 3NP
881751 | 3NP
881771 | 3NP
881831 | 3NP
881833 | 3NP
881834 | 3NP
881987 | 3NP
882002 | 3NP
882007 | 3NP
882031 | 3NP
882066 | 3NP
882073 | 3NP
882167 | 3NP
882177 | 3NP
882195 | 3NP
882215 | 3NP
882241 | 3NP
882263 | 3NP
882313 | 3NP
882315 | 3NP
882316 | 3NP
882317 | 3NP
882318 | 3NP
882319 | 3NP
882830 | 4NP
882910 | 4NP
882938 | 4NP
882982 | 4NP
882988 | 4NP
883015 | 4NP
883051 | 4NP
883074 | 4NP
883118 | 4NP
883138 | 4NP
883160 | 4NP
883180 | 4NP
883201 | 4NP
883253 | 4NP
883276 | 4NP
883297 | 4NP
883332 | 4NP
883342 | 4NP
883402 | 4NP
883419 | 4NP
883436 | 4NP
883474 | 4NP
883487 | 4NP
883501 | 4NP
883649 | 4NP
883662 | 4NP
883716 | 4NP
883767 | 4NP
883788 | 4NP
883796 | 4NP
883835 | 4NP
883840 | 4NP
883864 | 4NP
883895 | 4NP
883979 | 4NP
884036 | 4NP
884072 | 4NP
884095 | 4NP
884145 | 4NP
884193 | 4NP
884198 | 4NP
884221 | 4NP
884232 | 4NP
884248 | 4NP
884275 | 4NP
884307 | 4NP
884395 | 4NP
884402 | 4NP
884435 | 4NP
884447 | 4NP
884472 | 4NP
884489 | 4NP
884550 | 4NP
884595 | 4NP
884636 | 4NP
884665 | 4NP
884728 | 4NP
884738 | 4NP
884769 | 4NP
886014 | 4NP
887468 | 4NP
887536 | 4NP
888810 | 4NP
892721 | 1NP
892742 | 1NP
892809 | 1NP
913529 | 3NP
913530 | 3NP
928008 | 3NP
929502 | Podkroví
930478 | 3NP
930961 | 2NP

# IfcBuildingElementProxy: EF_Zásuvka:Jednozásuvka (153)
Type - Material: Plast bílý, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Jednozásuvka; sets with these values: 2
Name (EF_Zásuvka:Jednozásuvka:...) | In
842163 | 1PP
842176 | 1PP
842258 | 1PP
842342 | 1PP
842391 | 1PP
842570 | 1PP
842600 | 1PP
842940 | 1PP
843056 | 1PP
852189 | 1NP
852256 | 1NP
862725 | 1NP mezipatro
862735 | 1NP mezipatro
862776 | 1NP mezipatro
862783 | 1NP mezipatro
862789 | 1NP mezipatro
862795 | 1NP mezipatro
862801 | 1NP mezipatro
862807 | 1NP mezipatro
862813 | 1NP mezipatro
862819 | 1NP mezipatro
862829 | 1NP mezipatro
862838 | 1NP mezipatro
862854 | 1NP mezipatro
862895 | 1NP mezipatro
862902 | 1NP mezipatro
862908 | 1NP mezipatro
862914 | 1NP mezipatro
862920 | 1NP mezipatro
862926 | 1NP mezipatro
862932 | 1NP mezipatro
862954 | 1NP mezipatro
862961 | 1NP mezipatro
863053 | 1NP mezipatro
863246 | 1NP mezipatro
863705 | 1NP mezipatro
863724 | 1NP mezipatro
863741 | 1NP mezipatro
863748 | 1NP mezipatro
863754 | 1NP mezipatro
863760 | 1NP mezipatro
864281 | 1NP mezipatro
864299 | 1NP mezipatro
864317 | 1NP mezipatro
864325 | 1NP mezipatro
864347 | 1NP mezipatro
864419 | 1NP mezipatro
864440 | 1NP mezipatro
864472 | 1NP mezipatro
864508 | 1NP mezipatro
864599 | 1NP mezipatro
864623 | 1NP mezipatro
864650 | 1NP mezipatro
864687 | 1NP mezipatro
864747 | 1NP mezipatro
864787 | 1NP mezipatro
865577 | 1NP mezipatro
865586 | 1NP mezipatro
865631 | 1NP mezipatro
865645 | 1NP mezipatro
865668 | 1NP mezipatro
865735 | 1NP mezipatro
865790 | 2NP
865802 | 2NP
865833 | 2NP
865872 | 2NP
865889 | 2NP
865908 | 2NP
865927 | 2NP
865952 | 2NP
865991 | 2NP
866025 | 2NP
866051 | 2NP
866341 | 2NP
866360 | 2NP
866418 | 2NP
866424 | 2NP
866464 | 2NP
866490 | 2NP
866516 | 2NP
866535 | 2NP
866565 | 2NP
866608 | 2NP
866640 | 2NP
866678 | 2NP
866684 | 2NP
866713 | 2NP
866731 | 2NP
866751 | 2NP
866775 | 2NP
866801 | 2NP
866974 | 2NP
867119 | 2NP
867126 | 2NP
867165 | 2NP
867185 | 2NP
867226 | 2NP
867333 | 2NP
867430 | 2NP
867457 | 2NP
867463 | 2NP
867486 | 2NP
867512 | 2NP
867542 | 2NP
867627 | 2NP
867636 | 2NP
867668 | 2NP
867708 | 2NP
867747 | 2NP
867787 | 2NP
867794 | 2NP
867897 | 2NP
867916 | 2NP
868809 | 2NP
869177 | 2NP
869586 | 2NP
870015 | 2NP
870167 | 2NP
871945 | 2NP
871956 | 2NP
871994 | 2NP
872093 | 2NP
873136 | 2NP
873157 | 2NP
873212 | 2NP
873868 | 2NP
873921 | 2NP
875441 | 3NP
878089 | 3NP
878094 | 3NP
878124 | 3NP
878182 | 3NP
878205 | 3NP
878251 | 3NP
878272 | 3NP
878285 | 3NP
878324 | 3NP
880888 | 3NP
881010 | 3NP
881297 | 3NP
883546 | 4NP
883559 | 4NP
883571 | 4NP
883608 | 4NP
886040 | 4NP
886088 | 4NP
886121 | 4NP
886928 | 4NP
886945 | 4NP
887490 | 4NP
887751 | 4NP
889102 | 2NP
930877 | 2NP

# IfcDistributionPort (526)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
Port_840862_1
Port_840910_1
Port_840959_1
Port_840967_1
Port_841075_1
Port_841097_1
Port_841276_1
Port_841419_1
Port_841498_1
Port_841971_1
Port_842119_1
Port_842549_1
Port_842652_1
Port_842710_1
Port_842719_1
Port_842912_1
Port_842965_1
Port_842982_1
Port_843010_1
Port_843025_1
Port_843076_1
Port_843098_1
Port_843208_1
Port_843333_1
Port_843361_1
Port_843430_1
Port_843513_1
Port_843541_1
Port_843560_1
Port_843572_1
Port_843858_1
Port_843891_1
Port_843988_1
Port_844077_1
Port_844141_1
Port_844213_1
Port_844280_1
Port_844293_1
Port_844560_1
Port_844597_1
Port_844647_1
Port_844677_1
Port_844719_1
Port_844738_1
Port_844819_1
Port_844855_1
Port_844911_1
Port_852282_1
Port_852312_1
Port_852321_1
Port_852403_1
Port_852432_1
Port_852467_1
Port_852482_1
Port_852764_1
Port_852773_1
Port_853110_1
Port_853130_1
Port_853178_1
Port_853194_1
Port_853267_1
Port_853336_1
Port_853349_1
Port_853466_1
Port_853667_1
Port_854224_1
Port_854399_1
Port_854407_1
Port_854538_1
Port_854803_1
Port_854843_1
Port_855183_1
Port_856148_1
Port_856184_1
Port_861396_1
Port_861648_1
Port_861804_1
Port_861841_1
Port_861996_1
Port_862021_1
Port_862086_1
Port_862162_1
Port_862435_1
Port_863074_1
Port_863184_1
Port_863191_1
Port_863197_1
Port_863214_1
Port_863234_1
Port_863303_1
Port_863316_1
Port_863398_1
Port_863412_1
Port_863458_1
Port_863598_1
Port_863772_1
Port_863809_1
Port_863828_1
Port_863838_1
Port_863872_1
Port_863918_1
Port_864028_1
Port_864054_1
Port_864151_1
Port_864165_1
Port_864182_1
Port_864192_1
Port_864829_1
Port_864983_1
Port_865036_1
Port_865416_1
Port_865432_1
Port_866113_1
Port_866124_1
Port_866201_1
Port_866212_1
Port_866388_1
Port_866405_1
Port_866871_1
Port_866892_1
Port_866901_1
Port_866988_1
Port_866996_1
Port_867251_1
Port_867259_1
Port_867384_1
Port_867412_1
Port_867839_1
Port_867846_1
Port_867939_1
Port_867946_1
Port_868826_1
Port_868840_1
Port_868848_1
Port_868885_1
Port_868994_1
Port_869602_1
Port_869618_1
Port_869686_1
Port_869700_1
Port_869739_1
Port_870030_1
Port_870105_1
Port_870127_1
Port_870364_1
Port_870373_1
Port_870436_1
Port_870603_1
Port_870698_1
Port_870784_1
Port_870873_1
Port_870971_1
Port_871052_1
Port_871115_1
Port_871170_1
Port_871355_1
Port_871389_1
Port_871439_1
Port_871497_1
Port_871558_1
Port_871622_1
Port_871699_1
Port_871757_1
Port_871865_1
Port_872057_1
Port_872064_1
Port_873194_1
Port_873317_1
Port_873330_1
Port_873418_1
Port_873494_1
Port_873566_1
Port_873626_1
Port_873819_1
Port_873882_1
Port_874042_1
Port_874255_0
Port_874255_1
Port_874522_0
Port_874522_1
Port_874538_0
Port_874538_1
Port_874554_0
Port_874554_1
Port_874641_0
Port_874641_1
Port_874998_0
Port_874998_1
Port_875178_0
Port_875178_1
Port_875424_1
Port_877973_1
Port_878072_1
Port_878455_1
Port_878476_1
Port_878520_1
Port_878532_1
Port_878610_1
Port_878689_1
Port_878754_1
Port_878864_1
Port_878922_1
Port_879014_1
Port_879075_1
Port_879198_1
Port_879298_1
Port_879401_1
Port_879432_1
Port_879513_1
Port_879561_1
Port_879679_1
Port_879859_1
Port_879930_1
Port_879973_1
Port_880059_1
Port_880141_1
Port_880204_1
Port_880296_1
Port_880400_1
Port_880551_1
Port_880579_1
Port_880607_1
Port_880616_1
Port_880671_1
Port_880714_1
Port_880847_1
Port_880926_1
Port_880972_1
Port_881047_1
Port_881544_0
Port_881544_1
Port_881717_0
Port_881717_1
Port_881735_0
Port_881735_1
Port_881747_0
Port_881747_1
Port_881830_0
Port_881936_1
Port_881830_1
Port_881907_0
Port_881907_1
Port_881936_2
Port_882151_0
Port_882151_1
Port_882312_0
Port_882312_1
Port_882522_1
Port_882668_1
Port_882768_1
Port_884899_1
Port_884907_1
Port_884944_1
Port_884996_1
Port_885065_1
Port_885123_1
Port_885230_1
Port_885387_1
Port_885453_1
Port_885471_1
Port_885520_1
Port_885612_1
Port_885679_1
Port_885762_1
Port_885802_1
Port_885878_1
Port_885921_1
Port_886059_1
Port_886155_1
Port_886163_1
Port_886224_1
Port_886268_1
Port_886311_1
Port_886368_1
Port_886499_1
Port_886650_1
Port_886785_1
Port_886834_1
Port_886960_1
Port_886969_1
Port_887028_1
Port_887059_1
Port_887232_1
Port_887291_1
Port_887346_1
Port_887520_1
Port_887569_1
Port_887583_1
Port_887645_1
Port_887776_1
Port_887799_1
Port_887806_1
Port_887872_1
Port_887884_1
Port_887930_1
Port_887979_1
Port_888033_1
Port_888277_1
Port_888289_1
Port_888331_1
Port_888348_1
Port_888358_1
Port_888419_1
Port_888435_1
Port_888502_1
Port_888647_1
Port_888659_1
Port_888794_1
Port_888938_1
Port_889135_1
Port_889142_1
Port_898177_1
Port_898236_1
Port_898916_1
Port_898918_1
Port_898919_1
Port_898920_1
Port_898921_1
Port_898922_1
Port_898923_1
Port_899906_1
Port_902845_1
Port_902943_1
Port_903052_1
Port_903285_1
Port_909308_1
Port_910608_1
Port_910936_1
Port_911272_1
Port_911351_1
Port_911405_1
Port_911482_1
Port_911625_1
Port_911792_1
Port_911931_1
Port_911967_1
Port_912063_1
Port_912667_1
Port_912837_1
Port_913190_1
Port_913224_1
Port_913804_1
Port_914022_1
Port_914038_1
Port_914116_1
Port_914183_1
Port_914277_1
Port_914299_1
Port_914358_1
Port_914360_1
Port_914376_1
Port_914378_1
Port_914396_1
Port_914435_1
Port_915127_1
Port_915180_1
Port_915318_1
Port_915354_1
Port_915458_1
Port_915597_1
Port_915735_1
Port_915832_1
Port_916016_1
Port_916050_1
Port_916126_1
Port_916180_1
Port_916239_1
Port_916312_1
Port_916351_1
Port_916387_1
Port_916484_1
Port_916545_1
Port_917199_1
Port_917283_1
Port_917793_1
Port_918328_1
Port_918965_1
Port_919361_1
Port_919773_1
Port_919874_1
Port_920085_1
Port_920180_1
Port_920690_1
Port_920799_1
Port_920903_1
Port_921067_1
Port_921068_1
Port_921069_1
Port_922106_1
Port_922129_1
Port_922139_1
Port_922153_1
Port_922180_1
Port_922189_1
Port_922197_1
Port_922273_1
Port_922288_1
Port_922296_1
Port_922375_1
Port_922387_1
Port_922443_1
Port_922456_1
Port_922477_1
Port_922605_1
Port_922626_1
Port_922641_1
Port_922643_1
Port_922659_1
Port_922687_1
Port_922698_1
Port_922706_1
Port_923136_1
Port_923222_1
Port_923244_1
Port_923256_1
Port_923334_1
Port_923473_1
Port_923538_1
Port_923545_1
Port_923588_1
Port_923590_1
Port_923591_1
Port_923635_1
Port_923636_1
Port_923637_1
Port_923653_1
Port_923654_1
Port_923655_1
Port_923674_1
Port_923675_1
Port_923676_1
Port_923695_1
Port_923718_1
Port_923729_1
Port_923899_1
Port_923954_1
Port_923998_1
Port_924000_1
Port_924006_1
Port_924007_1
Port_924048_1
Port_924116_1
Port_924137_1
Port_924244_1
Port_924256_1
Port_924298_1
Port_924390_1
Port_924487_1
Port_924494_1
Port_924620_1
Port_924632_1
Port_924873_1
Port_924885_1
Port_924936_1
Port_926120_1
Port_926131_1
Port_926291_1
Port_926350_1
Port_926384_1
Port_926418_1
Port_926429_1
Port_926452_1
Port_926533_1
Port_926571_1
Port_926573_1
Port_926663_1
Port_926685_1
Port_926702_1
Port_926704_1
Port_926712_1
Port_926713_1
Port_926935_1
Port_926956_1
Port_926977_1
Port_926979_1
Port_926997_1
Port_927017_1
Port_927040_1
Port_927056_1
Port_927058_1
Port_927059_1
Port_927067_1
Port_927068_1
Port_927069_1
Port_927104_1
Port_927105_1
Port_927106_1
Port_927185_1
Port_927186_1
Port_927187_1
Port_927204_1
Port_927205_1
Port_927206_1
Port_927230_1
Port_927288_1
Port_927299_1
Port_927396_1
Port_927461_1
Port_927476_1
Port_927580_1
Port_927651_1
Port_927954_1
Port_927966_1
Port_928048_1
Port_928184_1
Port_928326_1
Port_928523_1
Port_928552_1
Port_928677_1
Port_928707_1
Port_929408_1
Port_929504_1
Port_929512_1
Port_930558_1
Port_930901_1
Port_930990_1
Port_931045_1
Port_931242_1
Port_931521_1
Port_931562_1
Port_931633_1
Port_931704_1
Port_931766_1
Port_931960_1
Port_951673_1
Port_951866_1

# IfcFlowFitting: M_Channel Horizontal Bend:Standard, M_Channel Horizontal Bend:Standard:881936
In: 3NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2

# IfcFlowSegment: Cable Tray with Fittings:Channel Cable Tray (15)
In: 3NP
Type - PredefinedType: CABLETRAYSEGMENT
Pset_DistributionFlowElementCommon - Reference: Channel Cable Tray; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Cable Tray with Fittings:Channel Cable Tray:...) | Length (mm)
874255 | 2040
874522 | 2040
874538 | 2040
874554 | 2040
874641 | 2040
874998 | 2040
875178 | 2040
881544 | 1060
881717 | 1060
881735 | 1060
881747 | 1060
881830 | 1487.4
881907 | 919.644
882151 | 1487.4
882312 | 1487.4

# IfcFlowTerminal: LF_Lineární světlo_face:1250x100 (7)
In: 4NP
Type - Material: <Unnamed>, Sklo
Pset_DistributionFlowElementCommon - Reference: 1250x100; sets with these values: 2
Name (LF_Lineární světlo_face:1250x100:...)
898916
898918
898919
898920
898921
898922
898923

# IfcFlowTerminal: LF_Lineární světlo_face:1250x250 (3)
Type - Material: <Unnamed>, Sklo
Pset_DistributionFlowElementCommon - Reference: 1250x250; sets with these values: 2
Name (LF_Lineární světlo_face:1250x250:...) | In
898177 | 4NP
898236 | 4NP
931633 | 1NP

# IfcFlowTerminal: LF_Lineární světlo_face:1450x120, LF_Lineární světlo_face:1450x120:903285
In: 1PP
Type - Material: <Unnamed>, Sklo
Pset_DistributionFlowElementCommon - Reference: 1450x120; sets with these values: 2

# IfcFlowTerminal: LF_Lineární světlo_face:1600x120 (2)
In: 1NP
Type - Material: <Unnamed>, Sklo
Pset_DistributionFlowElementCommon - Reference: 1600x120; sets with these values: 2
Name (LF_Lineární světlo_face:1600x120:...)
917199
917283

# IfcFlowTerminal: LF_Lineární světlo_face:2500x120 (10)
In: 1NP mezipatro
Type - Material: <Unnamed>, Sklo
Pset_DistributionFlowElementCommon - Reference: 2500x120; sets with these values: 2
Name (LF_Lineární světlo_face:2500x120:...)
919773
919874
920085
920180
920690
920799
920903
921067
921068
921069

# IfcFlowTerminal: LF_Lineární světlo_face:300x300 (10)
In: 1NP
Type - Material: <Unnamed>, Sklo
Pset_DistributionFlowElementCommon - Reference: 300x300; sets with these values: 2
Name (LF_Lineární světlo_face:300x300:...)
914277
914299
914358
914360
914376
914378
914396
914435
931045
931242

# IfcFlowTerminal: LF_Lineární světlo_face:3200x120, LF_Lineární světlo_face:3200x120:928707
In: 4NP
Type - Material: <Unnamed>, Sklo
Pset_DistributionFlowElementCommon - Reference: 3200x120; sets with these values: 2

# IfcFlowTerminal: LF_Lineární světlo_face:3600x120 (4)
In: 1NP mezipatro
Type - Material: <Unnamed>, Sklo
Pset_DistributionFlowElementCommon - Reference: 3600x120; sets with these values: 2
Name (LF_Lineární světlo_face:3600x120:...)
917793
918328
918965
919361

# IfcFlowTerminal: LF_Svítidlo do podhledu:600x600 (26)
In: 2NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 600x600; sets with these values: 2
Name (LF_Svítidlo do podhledu:600x600:...)
922106
922129
922139
922153
922180
922189
922197
922273
922288
922296
922375
922387
922443
922456
922477
922605
922626
922641
922643
922659
922687
922698
922706
923695
923718
923729

# IfcFlowTerminal: LF_Svítidlo nouzové nástěnné:Svítidlo nástěnné_nouzové (14)
Type - Material: <Unnamed>, Sklo, PVC, Flexible, Plastic
Pset_DistributionFlowElementCommon - Reference: Svítidlo nástěnné_nouzové; sets with these values: 2
Name (LF_Svítidlo nouzové nástěnné:Svítidlo nástěnné_nouzové:...) | In
902845 | 4NP
903052 | 4NP
914183 | 1NP mezipatro
915354 | 1NP
915832 | 2NP
916351 | 3NP
916545 | 2NP
928048 | 4NP
928184 | 4NP
930901 | 2NP
930990 | 2NP
931521 | 1NP
931562 | 1NP
931704 | 1NP

# IfcFlowTerminal: LF_Závěsné lineární svítidlo:1600x120 (63)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1600x120; sets with these values: 2
Name (LF_Závěsné lineární svítidlo:1600x120:...) | In
923473 | 2NP
923538 | 2NP
923545 | 2NP
923588 | 2NP
923590 | 2NP
923591 | 2NP
923635 | 2NP
923636 | 2NP
923637 | 2NP
923653 | 2NP
923654 | 2NP
923655 | 2NP
923674 | 2NP
923675 | 2NP
923676 | 2NP
923899 | 2NP
923954 | 2NP
923998 | 2NP
924000 | 2NP
924006 | 2NP
924007 | 2NP
924620 | 2NP
924632 | 2NP
924873 | 2NP
924885 | 2NP
926291 | 3NP
926350 | 3NP
926384 | 3NP
926418 | 3NP
926429 | 3NP
926663 | 3NP
926685 | 3NP
926702 | 3NP
926704 | 3NP
926712 | 3NP
926713 | 3NP
926935 | 3NP
926956 | 3NP
926977 | 3NP
926979 | 3NP
926997 | 3NP
927017 | 3NP
927040 | 3NP
927056 | 3NP
927058 | 3NP
927059 | 3NP
927067 | 3NP
927068 | 3NP
927069 | 3NP
927104 | 3NP
927105 | 3NP
927106 | 3NP
927185 | 3NP
927186 | 3NP
927187 | 3NP
927204 | 3NP
927205 | 3NP
927206 | 3NP
927230 | 3NP
927288 | 3NP
927299 | 3NP
927954 | 3NP
927966 | 3NP

# IfcFlowTerminal: LF_Závěsné lineární svítidlo:1900x120 (2)
In: 2NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 1900x120; sets with these values: 2
Name (LF_Závěsné lineární svítidlo:1900x120:...)
923136
923222

# IfcFlowTerminal: LF_Závěsné lineární svítidlo:2000x120 (2)
In: 3NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 2000x120; sets with these values: 2
Name (LF_Závěsné lineární svítidlo:2000x120:...)
927580
927651

# IfcFlowTerminal: LF_Závěsné lineární svítidlo:2080x120 (2)
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 2080x120; sets with these values: 2
Name (LF_Závěsné lineární svítidlo:2080x120:...)
928552
928677

# IfcFlowTerminal: LF_Závěsné lineární svítidlo:3000x300 (2)
In: 1NP mezipatro
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 3000x300; sets with these values: 2
Name (LF_Závěsné lineární svítidlo:3000x300:...)
913190
913224

# IfcFlowTerminal: LF_Závěsné lineární svítidlo:3250x120 (23)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 3250x120; sets with these values: 2
Name (LF_Závěsné lineární svítidlo:3250x120:...) | In
910608 | 1NP
923244 | 2NP
923256 | 2NP
923334 | 2NP
924048 | 2NP
924116 | 2NP
924137 | 2NP
924244 | 2NP
924256 | 2NP
924298 | 2NP
924390 | 2NP
924487 | 2NP
924494 | 2NP
924936 | 3NP
926120 | 3NP
926131 | 3NP
926452 | 3NP
926533 | 3NP
926571 | 3NP
926573 | 3NP
927396 | 3NP
927461 | 3NP
927476 | 3NP

# IfcFlowTerminal: LF_Závěsné lineární svítidlo:4400x300 (12)
In: 1NP mezipatro
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 4400x300; sets with these values: 2
Name (LF_Závěsné lineární svítidlo:4400x300:...)
910936
911272
911351
911405
911482
911625
911792
911931
911967
912063
912667
912837

# IfcFlowTerminal: LF_Závěsné lineární svítidlo:6350x120 (2)
In: 4NP
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 6350x120; sets with these values: 2
Name (LF_Závěsné lineární svítidlo:6350x120:...)
928326
928523

# IfcFlowTerminal: LF_Závěsné lineární svítidlo:8000x120 (3)
In: 1NP mezipatro
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 8000x120; sets with these values: 2
Name (LF_Závěsné lineární svítidlo:8000x120:...)
913804
914022
914038

# IfcFlowTerminal: LF_polokoule_face:LF_polokoule_face (18)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: LF_polokoule_face; sets with these values: 2
Name (LF_polokoule_face:LF_polokoule_face:...) | In
899906 | 4NP
902943 | 4NP
914116 | 1NP mezipatro
915127 | 1NP
915180 | 1NP
915318 | 1NP
915458 | 1NP
915597 | 1NP mezipatro
915735 | 2NP
916016 | 2NP
916050 | 3NP
916126 | 4NP
916180 | 2NP
916239 | 3NP
916312 | 3NP
916387 | 4NP
916484 | 2NP
929512 | 4NP
