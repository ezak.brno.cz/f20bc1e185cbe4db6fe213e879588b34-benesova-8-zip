Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: f778dcba-89dd-4728-8bfc-ebf020fbd298, NumberOfSaves: 30], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: D0089
Time: 2024-05-22T15:12:31+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENU) - IFC 24.1.1.6

# IfcProject, D0089
LongName: OÚPSŘ; Phase: DSPS

# IfcSite, Default
RefLatitude: 49, 11, 40, 133999; RefLongitude: 16, 36, 49, 660999; RefElevation: 0 mm

# IfcBuilding, Benešova 8
LongName: Benešova 8
Pset_BuildingCommon - NumberOfStoreys: 6

# IfcBuildingStorey: Level:Podlaží hlavní (8)
In: Benešova 8
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
1PP | 1PP | -3950.47
1NP | 1NP | 0
1NP mezipatro | 1NP mezipatro | 2649.53
2NP | 2NP | 5499.53
3NP | 3NP | 10199.5
4NP | 4NP | 14399.5
Podkroví | Podkroví | 17599.5
Střecha | Střecha | 26000

# IfcBuildingElementProxy: EF_Datová zásuvka:1 vývod (3)
Type - Material: Plast bílý, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 1 vývod; sets with these values: 2
Name (EF_Datová zásuvka:1 vývod:...) | In
835399 | 1PP
836869 | 1NP
867322 | 3NP

# IfcBuildingElementProxy: EF_Datová zásuvka:2 vývody (145)
Type - Material: Plast bílý, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 2 vývody; sets with these values: 2
Name (EF_Datová zásuvka:2 vývody:...) | In
835511 | 1NP
835717 | 1NP
835776 | 1NP
836525 | 1NP
836584 | 1NP
836590 | 1NP
836624 | 1NP
836692 | 1NP
836825 | 1NP
836879 | 1NP
836936 | 1NP
837032 | 1NP
837038 | 1NP
837120 | 1NP
837176 | 1NP
837341 | 1NP
837486 | 1NP
837554 | 1NP
837562 | 1NP
837641 | 1NP
837656 | 1NP
837690 | 1NP
863117 | 1NP
863124 | 1NP
863211 | 1NP
863257 | 1NP
863310 | 1NP
863448 | 1NP mezipatro
863492 | 1NP mezipatro
863565 | 1NP mezipatro
863574 | 1NP mezipatro
863743 | 1NP mezipatro
863876 | 1NP mezipatro
863889 | 1NP mezipatro
863918 | 1NP mezipatro
863924 | 1NP mezipatro
864034 | 1NP mezipatro
864042 | 1NP mezipatro
864082 | 1NP mezipatro
864142 | 1NP mezipatro
864149 | 1NP mezipatro
864180 | 1NP mezipatro
864187 | 1NP mezipatro
864220 | 1NP mezipatro
864227 | 1NP mezipatro
864274 | 1NP mezipatro
864282 | 1NP mezipatro
864296 | 1NP mezipatro
864352 | 1NP mezipatro
864403 | 2NP
864429 | 2NP
864466 | 2NP
864468 | 2NP
864492 | 2NP
864494 | 2NP
864529 | 2NP
864530 | 2NP
864569 | 2NP
864604 | 2NP
864655 | 2NP
864677 | 2NP
864700 | 2NP
864772 | 2NP
864835 | 2NP
864856 | 2NP
864863 | 2NP
864900 | 2NP
864958 | 2NP
864974 | 2NP
864987 | 2NP
864992 | 2NP
865025 | 2NP
865061 | 2NP
865280 | 2NP
865309 | 2NP
865406 | 2NP
865413 | 2NP
865476 | 2NP
865490 | 2NP
865560 | 2NP
865723 | 2NP
865730 | 2NP
865758 | 2NP
865790 | 2NP
865827 | 2NP
865857 | 2NP
865907 | 2NP
865962 | 2NP
866011 | 2NP
866070 | 2NP
866128 | 2NP
866197 | 2NP
866239 | 2NP
866285 | 2NP
866483 | 2NP
866508 | 2NP
866581 | 3NP
866588 | 3NP
866615 | 3NP
866652 | 3NP
866692 | 3NP
866807 | 3NP
866856 | 3NP
866861 | 3NP
866888 | 3NP
866943 | 3NP
866961 | 3NP
866974 | 3NP
866980 | 3NP
867060 | 3NP
867230 | 3NP
867439 | 3NP
867501 | 3NP
867538 | 3NP
867550 | 3NP
867566 | 3NP
867607 | 3NP
867616 | 3NP
867627 | 3NP
867673 | 3NP
867681 | 3NP
867712 | 3NP
867794 | 3NP
867857 | 3NP
867910 | 3NP
867956 | 3NP
867964 | 3NP
868006 | 3NP
868033 | 3NP
868057 | 3NP
868117 | 3NP
868182 | 3NP
868338 | 3NP
868829 | 4NP
868870 | 4NP
868896 | 4NP
868945 | 4NP
868947 | 4NP
868963 | 4NP
869068 | 4NP
875419 | 4NP
875425 | 4NP
875531 | 4NP
875622 | 4NP
878709 | 1NP

# IfcBuildingElementProxy: EF_Detektor pohybu:Detektor pohybu (6)
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Detektor pohybu; sets with these values: 2
Name (EF_Detektor pohybu:Detektor pohybu:...) | In
875834 | 4NP
876131 | 3NP
876189 | 3NP
876250 | 2NP
878276 | 1NP mezipatro
878394 | 1NP

# IfcBuildingElementProxy: EF_Klávesnice ZS:Klávesnice ZS, EF_Klávesnice ZS:Klávesnice ZS:878309
In: 1NP mezipatro
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Klávesnice ZS; sets with these values: 2

# IfcBuildingElementProxy: EF_TEL zásuvka:2 pin (2)
In: 4NP
Type - Material: <Unnamed>, Plast bílý
Pset_BuildingElementProxyCommon - Reference: 2 pin; sets with these values: 2
Name (EF_TEL zásuvka:2 pin:...)
875390
875679

# IfcBuildingElementProxy: EF_Tlačítko:Detektor pohybu (2)
In: 1NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Detektor pohybu; sets with these values: 2
Name (EF_Tlačítko:Detektor pohybu:...)
900813
900835

# IfcBuildingElementProxy: EF_Zvonky:Zvonky (4)
In: 1NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Zvonky; sets with these values: 2
Name (EF_Zvonky:Zvonky:...)
885604
885857
885873
885918

# IfcBuildingElementProxy: EF_Čidlo:Detektor pohybu (6)
In: 1NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Detektor pohybu; sets with these values: 2
Name (EF_Čidlo:Detektor pohybu:...)
893156
893271
893290
893303
893394
893480

# IfcBuildingElementProxy: EF_Čtečka karet:Čtečka karet (2)
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Čtečka karet; sets with these values: 2
Name (EF_Čtečka karet:Čtečka karet:...) | In
876309 | 2NP
878327 | 1NP mezipatro

# IfcBuildingElementProxy: GM_kamera:GM_kamera (11)
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: GM_kamera; sets with these values: 2
Name (GM_kamera:GM_kamera:...) | In
875757 | 4NP
875769 | 4NP
875808 | 4NP
875962 | 3NP
876021 | 3NP
876343 | 2NP
876382 | 2NP
878505 | 1NP
878620 | 1NP
885683 | 1NP
885767 | 1NP

# IfcDistributionControlElement: FD_Detektor kouře:Detektor kouře, FD_Detektor kouře:Detektor kouře:876417
In: 2NP
Type - Material: <Unnamed>
Pset_QuantityTakeOff - Reference: Detektor kouře

# IfcDistributionControlElement: FD_Optická signalizace:Optická signalizace, FD_Optická signalizace:Optická signalizace:877322
In: 2NP
Type - Material: <Unnamed>
Pset_QuantityTakeOff - Reference: Optická signalizace

# IfcDistributionPort, Port_876417_1
Description: Flow; FlowDirection: SOURCEANDSINK
